# IAR project Tpproject.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530F64.i51
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC2530F64_banked.xcl
configuration Release (8051)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\
  General.RTConfigPath: xxx.h
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  A8051.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    settings/: Untitled1.c
  group common
    common/cc8051/: hal_cc8051.h
    common/: hal_defs.h hal_int.c hal_types.h
  group interface
    targets/interface/: hal_assert.h hal_button.h hal_digio.h hal_int.h hal_joystick.h hal_lcd.h hal_led.h hal_mcu.h
  group rf/cc2530
    targets/interface/: hal_rf.h hal_rf_util.h
  group srf05_soc
    targets/srf05_soc/: hal_assert.c hal_board.c hal_board.h hal_button.c hal_digio.c hal_joystick.c hal_led.c
  group utilities
    utils/: util.c util.h util_lcd.c util_lcd.h util_menu.h
